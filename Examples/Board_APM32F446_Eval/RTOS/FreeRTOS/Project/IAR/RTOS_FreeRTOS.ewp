# IAR project RTOS_FreeRTOS.ewp, settings and files
configuration APM32F446 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F446xG Geehy APM32F446xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F445_446_SERIES; APM32F446_EVAL; APM32F446
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common; ..\..\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446\startup; ..\..\..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\..\Middlewares\OSIF; ..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Include
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32f446xG_128_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../../Source/: apm32f445_446_int.c main.c
  group Boards
    ../../../../../../Boards/: board.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F446/startup/iar/: startup_apm32f446.s
  group FreeRTOS
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Document
    ../../: readme.txt
  group OSIF
    ../../../../../../Middlewares/OSIF/: osif.c
  group Std
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_clock.c apm32f445_446_dma.c apm32f445_446_interrupt.c apm32f445_446_lpuart.c apm32f445_446_pins.c
  group UserConfig
    ../../Source/: user_clock_config.c
