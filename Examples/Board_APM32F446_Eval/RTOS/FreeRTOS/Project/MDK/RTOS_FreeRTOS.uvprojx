# Keil uVision project RTOS_FreeRTOS.uvprojx, settings and files
target APM32F446 (6220000::V6.22::ARMCLANG)
  device: APM32F446VGT7 Geehy
  pack: Geehy.APM32F445_446_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0000F000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_FreeRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APM32F445_446_SERIES,APM32F446_EVAL,APM32F446
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446\startup;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Middlewares\OSIF;..\..\..\..\..\..\Boards;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\FreeRTOS\FreeRTOSv202012.00\FreeRTOS\Source\portable\GCC\ARM_CM4F
  asm define: START_FROM_FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xf000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\apm32f446xG_128_flash.sct
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F446/startup/armc/: startup_apm32f446.S
  group Application
    ../../Source/: main.c apm32f445_446_int.c
  group OSIF
    ../../../../../../Middlewares/OSIF/: osif.c
  group Std
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_clock.c apm32f445_446_interrupt.c apm32f445_446_pins.c apm32f445_446_lpuart.c apm32f445_446_dma.c
  group Board
    ../../../../../../Boards/: board.c
  group Document
    ../../: readme.txt
  group UserConfig
    ../../Source/: user_clock_config.c
  group FreeRTOS
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/FreeRTOS/FreeRTOSv202012.00/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
