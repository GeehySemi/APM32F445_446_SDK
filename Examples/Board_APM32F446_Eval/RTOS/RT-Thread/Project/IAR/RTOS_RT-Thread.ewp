# IAR project RTOS_RT-Thread.ewp, settings and files
configuration APM32F446 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F446xG Geehy APM32F446xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F445_446_SERIES; APM32F446_EVAL; APM32F446
  ICCARM.CCDiagSuppress: Pa181
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common; ..\..\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446\startup; ..\..\..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\..\Middlewares\OSIF; ..\..\..\..\..\..\Middlewares\RT-Thread\rtthread-nano-master\rt-thread\include; ..\..\..\..\..\..\Middlewares\RT-Thread\rtthread-nano-master\rt-thread\components\finsh
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32f446xG_128_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../../Source/: apm32f445_446_int.c main.c
  group Boards
    ../../../../../../Boards/: board.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ./: startup_apm32f446.s
  group Finsh
    ../../../../../../Middlewares/RT-Thread/rtthread-nano-master/rt-thread/components/finsh/: cmd.c msh.c shell.c
    ../../Source/: finsh_port.c
  group Document
    ../../: readme.txt
  group OSIF
    ../../../../../../Middlewares/OSIF/: osif.c
  group RT-Thread
    ../../../../../../Middlewares/RT-Thread/rtthread-nano-master/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../../../../Middlewares/RT-Thread/rtthread-nano-master/rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
    ../../Source/: rtthread_board.c
  group Std
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_clock.c apm32f445_446_dma.c apm32f445_446_interrupt.c apm32f445_446_lpuart.c apm32f445_446_pins.c
  group UserConfig
    ../../Source/: user_clock_config.c
