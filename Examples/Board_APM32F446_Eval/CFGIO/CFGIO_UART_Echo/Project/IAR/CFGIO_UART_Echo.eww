<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CFGIO_UART_Echo.ewp</path>
    </project>
    <batchBuild />
</workspace>
