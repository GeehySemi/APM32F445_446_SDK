# IAR project CFGIO_I2C_Master.ewp, settings and files
configuration APM32F446 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F446xG Geehy APM32F446xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F445_446_SERIES; APM32F446_EVAL; APM32F446
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common; ..\..\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F446\startup; ..\..\..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\..\Middlewares\OSIF
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CFGIO_I2C_Master.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32f446xG_128_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application/Include
    ../../Include/: apm32f445_446_int.h
  group Application/Src
    ../../Source/: apm32f445_446_int.c main.c
  group Boards/Include
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F446/: apm32f446_features.h
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/: apm32f445_446.h
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F446/startup/: startup.h system_apm32f445_446.h
  group Boards/Src
    ../../../../../../Boards/: board.c
  group CMSIS/Include
    ../../../../../../Libraries/CMSIS/Include/: core_cm4.h
  group CMSIS/Src
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F446/startup/iar/: startup_apm32f446.s
  group Document
    ../../: readme.txt
  group OSIF/Include
    ../../../../../../Middlewares/OSIF/: osif.h
  group OSIF/Src
    ../../../../../../Middlewares/OSIF/: osif.c
  group Std/Include
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/inc/: apm32f445_446_clock.h apm32f445_446_dma.h apm32f445_446_cfgio_common.h apm32f445_446_cfgio_i2c.h apm32f445_446_cfgio_spi.h apm32f445_446_cfgio_uart.h apm32f445_446_interrupt.h apm32f445_446_lpi2c.h apm32f445_446_lpuart.h apm32f445_446_pins.h
  group Std/Src
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_clock.c apm32f445_446_dma.c apm32f445_446_cfgio_common.c apm32f445_446_cfgio_i2c.c apm32f445_446_interrupt.c apm32f445_446_lpi2c.c apm32f445_446_lpuart.c apm32f445_446_pins.c
  group UserConfig/Include
    ../../Include/: user_clock_config.h user_config.h user_dma_config.h user_cfgio_i2c_config.h user_lpi2c_config.h user_pin_gpio_config.h
  group UserConfig/Src
    ../../Source/: user_clock_config.c user_dma_config.c user_cfgio_i2c_config.c user_lpi2c_config.c user_pin_gpio_config.c
