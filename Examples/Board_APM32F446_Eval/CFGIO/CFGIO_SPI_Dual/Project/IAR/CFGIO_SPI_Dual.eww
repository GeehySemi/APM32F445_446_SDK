<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CFGIO_SPI_Dual.ewp</path>
    </project>
    <batchBuild />
</workspace>
