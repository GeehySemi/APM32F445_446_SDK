<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CFGTMR1_OCToggle.ewp</path>
    </project>
    <batchBuild />
</workspace>
