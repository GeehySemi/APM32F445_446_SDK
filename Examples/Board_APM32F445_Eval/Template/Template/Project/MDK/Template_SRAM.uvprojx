# Keil uVision project Template_SRAM.uvprojx, settings and files
target APM32F445 (6160000::V6.16::ARMCLANG)
  device: APM32F445VET7 Geehy
  pack: Geehy.APM32F445_446_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template_SRAM
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APM32F445_446_SERIES,APM32F445_EVAL,APM32F445
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445\startup;..\..\..\..\..\..\Libraries\CMSIS\Core\Include;..\..\..\..\..\..\Middlewares\OSIF;..\..\..\..\..\..\Boards
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445\linker\armc\apm32f445_64_ram.sct
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F445/startup/armc/: startup_apm32f445.S
  group Application
    ../../Source/: main.c apm32f445_446_int.c
  group OSIF
    ../../../../../../Middlewares/OSIF/: osif.c
  group Std
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_adc.c apm32f445_446_clock.c apm32f445_446_comp.c apm32f445_446_crc.c apm32f445_446_csec.c apm32f445_446_dma.c apm32f445_446_einj.c apm32f445_446_erep.c apm32f445_446_ewdt.c apm32f445_446_flash.c apm32f445_446_can.c apm32f445_446_cfgtmr.c apm32f445_446_interrupt.c apm32f445_446_lpi2c.c apm32f445_446_lpitmr.c apm32f445_446_lpspi.c apm32f445_446_lptmr.c apm32f445_446_lpuart.c apm32f445_446_mpu.c apm32f445_446_pdu.c apm32f445_446_pins.c apm32f445_446_power.c apm32f445_446_rtc.c apm32f445_446_tmc.c apm32f445_446_wdt.c apm32f445_446_cfgio_common.c apm32f445_446_cfgio_i2c.c apm32f445_446_cfgio_spi.c apm32f445_446_cfgio_uart.c
  group Board
    ../../../../../../Boards/: board.c
  group Document
    ../../: readme.txt
