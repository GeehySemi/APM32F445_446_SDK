<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PINS_Isr.ewp</path>
    </project>
    <batchBuild />
</workspace>
