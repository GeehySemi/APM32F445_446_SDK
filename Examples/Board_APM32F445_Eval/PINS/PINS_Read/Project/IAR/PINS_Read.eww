<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PINS_Read.ewp</path>
    </project>
    <batchBuild />
</workspace>
