# Keil uVision project RTOS_RT-Thread.uvprojx, settings and files
target APM32F445 (6220000::V6.22::ARMCLANG)
  device: APM32F445VET7 Geehy
  pack: Geehy.APM32F445_446_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_RT-Thread
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APM32F445_446_SERIES,APM32F445_EVAL,APM32F445
  c misc: -Wno-macro-redefined
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445\startup;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Middlewares\OSIF;..\..\..\..\..\..\Boards;..\..\..\..\..\..\Middlewares\RT-Thread\rtthread-nano-master\rt-thread\include;..\..\..\..\..\..\Middlewares\RT-Thread\rtthread-nano-master\rt-thread\components\finsh
  asm define: START_FROM_FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\apm32f445xE_64_flash.sct
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F445/startup/armc/: startup_apm32f445.S
  group Application
    ../../Source/: main.c apm32f445_446_int.c
  group OSIF
    ../../../../../../Middlewares/OSIF/: osif.c
  group Std
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_clock.c apm32f445_446_interrupt.c apm32f445_446_pins.c apm32f445_446_lpuart.c apm32f445_446_dma.c
  group Board
    ../../../../../../Boards/: board.c
  group Document
    ../../: readme.txt
  group UserConfig
    ../../Source/: user_clock_config.c
  group RT-Thread
    ../../Source/: rtthread_board.c
    ../../../../../../Middlewares/RT-Thread/rtthread-nano-master/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../../../../Middlewares/RT-Thread/rtthread-nano-master/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Finsh
    ../../Source/: finsh_port.c
    ../../../../../../Middlewares/RT-Thread/rtthread-nano-master/rt-thread/components/finsh/: cmd.c msh.c shell.c
