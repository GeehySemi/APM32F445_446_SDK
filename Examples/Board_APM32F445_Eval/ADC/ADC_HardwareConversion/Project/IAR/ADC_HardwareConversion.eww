<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_HardwareConversion.ewp</path>
    </project>
    <batchBuild />
</workspace>
