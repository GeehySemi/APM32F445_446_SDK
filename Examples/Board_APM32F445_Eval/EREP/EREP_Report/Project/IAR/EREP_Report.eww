<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EREP_Report.ewp</path>
    </project>
    <batchBuild />
</workspace>
