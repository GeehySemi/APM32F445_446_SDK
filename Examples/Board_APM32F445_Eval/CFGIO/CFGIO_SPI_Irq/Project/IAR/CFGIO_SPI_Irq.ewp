# IAR project CFGIO_SPI_Irq.ewp, settings and files
configuration APM32F445 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F445xE Geehy APM32F445xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F445_446_SERIES; APM32F445_EVAL; APM32F445
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Boards; ..\..\..\..\..\..\Libraries\APM32F445_446_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\common; ..\..\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F445_446\APM32F445\startup; ..\..\..\..\..\..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\..\Middlewares\OSIF
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FLASH_Partition.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: apm32f445xE_64_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Application
    ../../Source/: apm32f445_446_int.c main.c
  group Boards
    ../../../../../../Boards/: board.c
  group CMSIS
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/common/: startup.c system_apm32f445_446.c
    ../../../../../../Libraries/Device/Geehy/APM32F445_446/APM32F445/startup/iar/: startup_apm32f445.s
  group Document
    ../../: readme.txt
  group OSIF
    ../../../../../../Middlewares/OSIF/: osif.c
  group Std
    ../../../../../../Libraries/APM32F445_446_StdPeriphDriver/src/: apm32f445_446_cfgio_common.c apm32f445_446_cfgio_spi.c apm32f445_446_clock.c apm32f445_446_dma.c apm32f445_446_interrupt.c apm32f445_446_lpuart.c apm32f445_446_pins.c
  group User_Config
    ../../Source/: user_cfgio_spi_config.c user_clock_config.c user_pin_gpio_config.c
